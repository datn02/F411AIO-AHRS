# Keil uVision project F411_AHRS.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32F411CCUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: F411_AHRS +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: global.h ibus.c ibus.h LED_Config.c LED_Config.h MahonyAHRS.c MahonyAHRS.h main.c mixer.c mixer.h mpu6000.c mpu6000.h pid.c pid.h RCC_Config.c RCC_Config.h SPI.c SPI.h task.c task.h timer.c timer.h usart.c usart.h complementary_filter.c complementary_filter.h
software components: CMSIS:CORE 5.4.0, Device:Startup 2.6.3
